## config/boards/shields/frotoberry/Kconfig.defconfig
```kconfig
if SHIELD_FROTOBERRY

config ZMK_KEYBOARD_NAME 
    default "frotoberry" 

    endif
```
